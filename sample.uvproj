# Keil uVision project sample.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: sample
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup_file
    ./: startup_LPC17xx.s
  group main
    ./: sample.c
  group System on Chip - Board
    ./: core_cm3.c system_LPC17xx.c
  group Leds
    ./led/: funct_led.c lib_led.c led.h
  group Buttons
    ./button/: button.h IRQ_button.c lib_button.c
  group Joystick
    ./joystick/: joystick.h lib_joystick.c funct_joystick.c
  group ADC
    ./ADC/: adc.h IRQ_adc.c lib_adc.c
  group DAC
    ./DAC/: dac.h lib_dac.c
  group RIT
    ./RIT/: IRQ_RIT.c lib_RIT.c RIT.h
  group Timers
    ./timer/: IRQ_timer.c lib_timer.c timer.h
  group Graphic LCD
    ./GLCD/: ascii.c ascii.h glcd.h hz.c hz.h lib_glcd.c
  group Touch Panel
    ./touchpanel/: touchpanel.c touchpanel.h
  group Elevator
    ./elevator/: elevator.h lib_elevator.c
    ./elevator/maintenance/: lib_maintenance.c maintenance.h
    ./Elevator/Emergency/: emergency.h lib_emergency.c
